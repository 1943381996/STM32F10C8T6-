# Keil uVision project STM32F103C8T6_LYX_OPEN.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103C8T6_LYX_OPEN +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: SSTM32F10X_XL,USE_STDPERIPH_DRIVER
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\STM32F10x_StdPeriph_Driver\src;.\DRIVER\C;.\DRIVER\H;.\Libraries\DSP_library\Include;.\Libraries\DSP_library
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ./Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f10x.c
  group DRIVER_C
    ./DRIVER/C/: test.c LYX_SPI.c LYX_ADC.c LYX_CLOCK.c LYX_DELAY.c LYX_DMA.c LYX_FFT.c LYX_FONT.c LYX_GPIO.c LYX_IIC.c LYX_KEY.c LYX_PWM.c LYX_TIME.c LYX_WS2812B.c LYX_OLED_IIC.c LYX_OLED_SPI.c LYX_USART.c
  group DRIVER_H
    ./DRIVER/H/: test.h LYX_SPI.h LYX_ADC.h LYX_CLOCK.h LYX_DELAY.h LYX_DMA.h LYX_FFT.h LYX_FONT.h LYX_GPIO.h LYX_IIC.h LYX_KEY.h LYX_PWM.h LYX_TIME.h LYX_WS2812B.h LYX_OLED_IIC.h LYX_OLED_SPI.h LYX_USART.h
  group USER
    ./User/: main.c headfile.h
    ./DRIVER/H/: common.h
  group DOC
    ./DOC/: 说明.txt
  group DSP_lib
    ./Libraries/DSP_library/: table_fft.h stm32_dsp.h cr4_fft_64_stm32.s cr4_fft_256_stm32.s cr4_fft_1024_stm32.s
software components: RTOS:kernel 3.1.5
